# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c misc: --locale=english
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\ZNGL;..\HARDWARE\rs485;..\HARDWARE\CRC;..\SYSTEM\delay;..\HARDWARE\usart_tft;..\HARDWARE\usart_tft;..\HARDWARE\KEY;..\SYSTEM\usart;..\USER;..\USER;..\HARDWARE\DHT11;..\HARDWARE\CH376;..\SYSTEM\language;..\SYSTEM\crc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c config.h exdata_process.c
  group HARDWARE
    ./: 24cxx.c myiic.c w25qxx.c spi.c
    ../HARDWARE/ZNGL/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DHT11/: dht11.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ./: IWDG.c timer2.c timer3.c timer4.c usart1.c usart2.c usart3.c
    ../HARDWARE/ZNGL/: timer1.c
    ../SYSTEM/language/: language.c
    ../SYSTEM/crc/: crc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_spi.c
  group README
    ../: README.TXT
  group Usart_TFT
    ../HARDWARE/usart_tft/: cmd_queue.c hmi_driver.c hmi_user_uart.c hw_config.c
  group CH376
    ../HARDWARE/CH376/: FILE_SYS.C HAL_BASE.C UART_HW.C
